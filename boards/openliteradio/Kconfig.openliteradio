## boards/openliteradio/board.yml
```yaml
board:
  name: openliteradio
  full_name: OpenLiteRadio STM32-compatible feasibility target
  vendor: others
  socs:
    - name: stm32f103xb
```
